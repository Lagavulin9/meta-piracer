DESCRIPTION = "\
    A template image inheriting the base image. This image recipe  \
    should be used as an example once the project decides to create \
    its own project specific image based on base.                  \
"

inherit core-image-base